FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Set to 1 to forcibly skip OverlayFS, and default to copy+bind
AVOID_OVERLAYFS = "1"

