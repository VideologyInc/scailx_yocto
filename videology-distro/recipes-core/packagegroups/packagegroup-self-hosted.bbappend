RDEPENDS:packagegroup-self-hosted-extended:remove = "settings-daemon"
RDEPENDS:packagegroup-self-hosted-graphics:remove = "pcmanfm"
