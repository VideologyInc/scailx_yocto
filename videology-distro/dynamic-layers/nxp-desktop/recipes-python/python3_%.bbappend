
do_install:append() {
    rm -rf ${D}${bindir}/python3
}