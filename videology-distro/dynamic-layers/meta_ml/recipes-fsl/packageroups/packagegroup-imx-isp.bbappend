ISP_PKGS:remove:mx8mp-nxp-bsp = " basler-camera basler-camera-dev "
