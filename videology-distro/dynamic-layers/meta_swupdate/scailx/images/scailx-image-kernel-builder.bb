DESCRIPTION = "Scailx image able to build loadable modules."

require scailx-image-swupdate-ml.bb

inherit kernel_devel