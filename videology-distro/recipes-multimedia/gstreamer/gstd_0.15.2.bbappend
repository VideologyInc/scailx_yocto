FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Add-list-all-elements-functionality-to-list_elements.patch"

