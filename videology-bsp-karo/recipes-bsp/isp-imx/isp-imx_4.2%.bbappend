FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-delay-isp-imx-script-and-make-sure-it-modprobes-imx8.patch"

