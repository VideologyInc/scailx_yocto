FILESEXTRAPATHS:prepend := "${THISDIR}/files/patches/linux-6.6:"

RDEPENDS:kernel-modules += "rtw88-mod"