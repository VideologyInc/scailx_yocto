FILESEXTRAPATHS:prepend := "${THISDIR}/files/patches/linux-6.1:"

RDEPENDS:kernel-modules += "rtl88x2bu-mod"