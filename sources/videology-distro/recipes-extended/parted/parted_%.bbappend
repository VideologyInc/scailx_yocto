PACKAGES_remove[karo-minimal] = "${PN}-ptest"
RDEPENDS_${PN}-ptest_remove[karo-minimal] = "bash coreutils perl util-linux-losetup python3"
