PACKAGECONFIG_append_tx6 = " etnaviv kmsro opengl egl gles gbm dri gallium"
PACKAGECONFIG_append_stm32mp1 = " etnaviv kmsro opengl egl gles gbm dri gallium"
