EXTRA_OEMAKE += "builddir_name=."
