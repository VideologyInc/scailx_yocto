# etnaviv mesa does not have glx
PACKAGECONFIG_remove = "xcomposite-glx"
