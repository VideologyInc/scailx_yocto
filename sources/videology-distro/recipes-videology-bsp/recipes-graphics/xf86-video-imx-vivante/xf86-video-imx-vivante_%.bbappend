COMPATIBLE_MACHINE_mx8 = "(mx8)"
