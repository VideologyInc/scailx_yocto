# remove nxp-demo-experience since it collides with our weston-init
RDEPENDS_${PN}_remove = "nxp-demo-experience"
