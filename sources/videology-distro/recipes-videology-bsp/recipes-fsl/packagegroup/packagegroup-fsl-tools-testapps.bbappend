RDEPENDS_${PN}_remove = "can-utils"
