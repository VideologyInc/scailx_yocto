INITSCRIPT_NAME = "hostapd"
