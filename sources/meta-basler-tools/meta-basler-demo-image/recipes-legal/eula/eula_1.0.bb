LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://eula.txt;md5=c500526bbae0f0f8454b5d5b66d74914"

SRC_URI = "file://eula.txt"

patch[noexec] = "1"
configure[noexec] = "1"
compile[noexec] = "1"
install[noexec] = "1"
